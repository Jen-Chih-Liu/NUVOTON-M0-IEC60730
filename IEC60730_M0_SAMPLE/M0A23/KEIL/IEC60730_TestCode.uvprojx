# Keil uVision project IEC60730_TestCode.uvprojx, settings and files
target IEC60730_TestCode (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: M0A23OC1AC Nuvoton
  pack: Nuvoton.NuMicro_DFP.1.3.17
  cpu: IRAM(0x20000000,0x1000) IROM(0x00000000,0x8000) CPUTYPE("Cortex-M0") CLOCK(12000000)
  output: IEC60730_ClassB_Test
  AfterMake: fromelf --bin ".\obj\@L.axf" --output ".\obj\@L.bin"
  AfterMake: fromelf --text -c ".\obj\@L.axf" --output ".\obj\@L.txt"
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: M0A32
  c include: ..\..\..\..\Library\CMSIS\Include;..\..\..\..\Library\Device\Nuvoton\M0A21\Include;..\..\..\..\Library\StdDriver\inc;..\;..\..\..\IEC60730_M0_STL
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x1000
  scatter file: .\iec60730.sct
  link misc: --map --datacompressor=off --info=inline --entry Reset_Handler
  group CMSIS
    ../../../../Library/Device/Nuvoton/M0A21/Source/: system_M0A21.c
    ../../../../Library/Device/Nuvoton/M0A21/Source/ARM/: startup_M0A21.s
  group Library
    ../../../../Library/StdDriver/src/: retarget.c uart.c clk.c timer.c sys.c gpio.c adc.c fmc.c crc.c wwdt.c wdt.c
  group User
    ../: main.c system_init.c
  group IEC60730_SAFETY_TEST_LIB
    ../../../IEC60730_M0_STL/: adc_mux_test_runtime.c cpureg_test_runtime.s cpureg_test_startup.s flash_test_runtime.c flash_test_startup.c global_var.c global_var_backup.c interrupt_test_runtime.c pc_test_startup.c ram_march_test.c ram_marchc_wom_test_runtime.s ram_marchc_wom_test_startup.s ram_marchx_wom_test_startup.s stack_overrun_ptrn.c stack_test_runtime.c
  group IEC60730_SAFETY_CONTROL
    ../../../IEC60730_M0_STL/: CLASSB_RUNTIME_TESTS.c CLASSB_STARTUP_TESTS.c CLASSB_TESTLIB_INIT.c IEC60730_SAFETY_TEST_LIB.c IEC60730_SAFETY_TEST_LIB.h
software components: CMSIS:CORE 5.5.0
